options:
  parameters:
    author: citizenrich
    generate_options: qt_gui
    id: onedimension_usrp_b210
    output_language: python
    realtime_scheduling: '1'
    title: onedimension_usrp_b120
  states: {}

blocks:
- name: columns
  id: variable
  parameters:
    value: '100'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '10'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 422e6
  states: {}
- name: gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: keep
  id: variable
  parameters:
    value: '10'
  states: {}
- name: left
  id: variable
  parameters:
    value: np.pad(shiftarrL, (0, int(columns/2)), 'constant')
  states: {}
- name: maxmag
  id: variable
  parameters:
    value: '.002'
  states: {}
- name: maxtheta
  id: variable_qtgui_range
  parameters:
    label: max degrees lag
    orient: Qt.Horizontal
    start: '10'
    step: '5'
    stop: '180'
    value: '140'
  states: {}
- name: minmag
  id: variable
  parameters:
    value: '0.000005'
  states: {}
- name: right
  id: variable
  parameters:
    value: np.flip(left, axis=0)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: scale
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '5000'
    stop: '100000'
    value: '60000'
  states: {}
- name: shiftarrL
  id: variable
  parameters:
    value: np.radians(np.linspace(start=maxtheta, stop=0, num=int(columns/2), endpoint=False))
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    label: squelch threshold
    orient: Qt.Horizontal
    rangeType: int
    start: '-160'
    step: '5'
    stop: '-10'
    value: '-60'
  states: {}
- name: variable_function_probe_0
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_0
    function_name: level
    poll_rate: '1'
    value: '1'
  states: {}
- name: variable_function_probe_0_0
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_0_0
    function_name: level
    poll_rate: '1'
    value: '0'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 'tab@2: 0,0'
    label: Left steering array
    type: raw
    value: left
  states: {}
- name: variable_qtgui_label_0_0
  id: variable_qtgui_label
  parameters:
    label: Probe Signal Max
    type: int
    value: variable_function_probe_0
  states: {}
- name: variable_qtgui_label_0_0_0
  id: variable_qtgui_label
  parameters:
    label: Probe Signal Min
    type: int
    value: variable_function_probe_0_0
  states: {}
- name: variable_qtgui_label_0_1
  id: variable_qtgui_label
  parameters:
    gui_hint: 'tab@2: 1,0'
    label: Right steering array
    type: raw
    value: right
  states: {}
- name: vlen
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'False'
    ramp: '0'
    threshold: threshold
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'False'
    ramp: '0'
    threshold: threshold
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters:
    vlen: vlen
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_0_0_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_0_0_0_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_float_to_short_0_1_0
  id: blocks_float_to_short
  parameters:
    scale: scale
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: keep
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: keep
    type: complex
  states: {}
- name: blocks_magphase_to_complex_0_0_0_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {}
- name: blocks_magphase_to_complex_0_0_0_0_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: int(samp_rate/keep)
    vlen_out: '1'
  states: {}
- name: blocks_min_xx_0
  id: blocks_min_xx
  parameters:
    type: float
    vlen: int(samp_rate/keep)
    vlen_out: '1'
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: vlen
  states: {}
- name: blocks_probe_signal_x_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_probe_signal_x_0_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0_0_0_0
  id: blocks_repeat
  parameters:
    interp: columns
    type: float
  states: {}
- name: blocks_repeat_0_0_0_0_0
  id: blocks_repeat
  parameters:
    interp: columns
    type: float
  states: {}
- name: blocks_repeat_0_0_0_0_0_1
  id: blocks_repeat
  parameters:
    interp: columns
    type: float
  states: {}
- name: blocks_repeat_0_0_0_0_1
  id: blocks_repeat
  parameters:
    interp: columns
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vlen
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vlen
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: int(samp_rate/keep)
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: left
  states: {}
- name: blocks_vector_source_x_0_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: right
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: tab@0
    ncols: columns
    nrows: columns
    samp_rate: int(samp_rate/keep)
    type: float
    update_time: '0.01'
    zmax: maxmag
    zmin: minmag
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.1'
    gui_hint: tab@1
    showports: 'True'
    update_time: '0.01'
    vlen: vlen
    x_start: '0'
    x_step: '1.0'
    ymax: '4'
    ymin: '-4'
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Time Raster
    label1: Phase sink
    label2: Steering lags
    num_tabs: '3'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    center_freq0: freq
    center_freq1: freq
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_args: '"type=b200, name=newb210"'
    gain0: gain
    gain1: gain
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: video_sdl_sink_1_1_0
  id: video_sdl_sink
  parameters:
    display_height: columns*5
    display_width: columns*5
    fps: '0'
    height: columns
    type: short
    width: columns
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', blocks_keep_one_in_n_0_0, '0']
- [analog_pwr_squelch_xx_0, '0', blocks_stream_to_vector_0_0, '0']
- [analog_pwr_squelch_xx_0_0, '0', blocks_keep_one_in_n_0, '0']
- [analog_pwr_squelch_xx_0_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_add_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_complex_to_arg_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_float_to_short_0_1_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_raster_sink_x_0, '0']
- [blocks_complex_to_magphase_0_0_0, '0', blocks_repeat_0_0_0_0, '0']
- [blocks_complex_to_magphase_0_0_0, '1', blocks_repeat_0_0_0_0_0, '0']
- [blocks_complex_to_magphase_0_0_0_0, '0', blocks_repeat_0_0_0_0_1, '0']
- [blocks_complex_to_magphase_0_0_0_0, '1', blocks_repeat_0_0_0_0_0_1, '0']
- [blocks_float_to_short_0_1_0, '0', video_sdl_sink_1_1_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_complex_to_magphase_0_0_0, '0']
- [blocks_keep_one_in_n_0_0, '0', blocks_complex_to_magphase_0_0_0_0, '0']
- [blocks_magphase_to_complex_0_0_0_0, '0', blocks_add_xx_0, '0']
- [blocks_magphase_to_complex_0_0_0_0_0, '0', blocks_add_xx_0, '1']
- [blocks_max_xx_0, '0', blocks_probe_signal_x_0, '0']
- [blocks_min_xx_0, '0', blocks_probe_signal_x_0_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_repeat_0_0_0_0, '0', blocks_magphase_to_complex_0_0_0_0, '0']
- [blocks_repeat_0_0_0_0_0, '0', blocks_sub_xx_0_0, '0']
- [blocks_repeat_0_0_0_0_0_1, '0', blocks_sub_xx_0_0_0, '0']
- [blocks_repeat_0_0_0_0_1, '0', blocks_magphase_to_complex_0_0_0_0_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [blocks_stream_to_vector_0_1, '0', blocks_max_xx_0, '0']
- [blocks_stream_to_vector_0_1, '0', blocks_min_xx_0, '0']
- [blocks_sub_xx_0_0, '0', blocks_magphase_to_complex_0_0_0_0, '1']
- [blocks_sub_xx_0_0_0, '0', blocks_magphase_to_complex_0_0_0_0_0, '1']
- [blocks_vector_source_x_0_0_0, '0', blocks_sub_xx_0_0, '1']
- [blocks_vector_source_x_0_0_0_0, '0', blocks_sub_xx_0_0_0, '1']
- [uhd_usrp_source_0, '0', analog_pwr_squelch_xx_0_0, '0']
- [uhd_usrp_source_0, '1', analog_pwr_squelch_xx_0, '0']

metadata:
  file_format: 1
